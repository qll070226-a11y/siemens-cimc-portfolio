# Keil uVision project CIMC_APP.uvprojx, settings and files
target McuSTUDIO_F470VET6 (6240000::V6.24::ARMCLANG)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: ./keil5_disp_size_bar.exe
  AfterMake: fromelf --bin --output=.\output\App.bin .\output\Project.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F470,__PERF_COUNTER_CFG_USE_SYSTICK_WRAPPER__
  c include: ..\Libraries\Include;..\CMSIS\CMSIS_6.2.0\CMSIS\Core\Include;..\CMSIS\CMSIS_6.2.0\CMSIS\Core\Include\a-profile;..\CMSIS\CMSIS_6.2.0\CMSIS\Core\Include\m-profile;..\CMSIS\CMSIS_6.2.0\CMSIS\Core\Include\r-profile;..\CMSIS;..\CMSIS\GD\GD32F4xx\Include;..\DeviceLib\BoardSupport;..\DeviceLib\OledBus;..\DeviceLib\SpiFlash;..\DeviceLib\KeyEngine;..\DeviceLib\SdCard;..\DeviceLib\ExternalAdc;..\DeviceLib\FileSystem;..\Driver;..\HeaderFiles;..\Function\AppTask;..\PACK\perf_counter-2.5.4;..\Protocol;..\Function;..\ThirdParty\FreeModbus\include;..\ThirdParty\FreeModbus\port;..\ThirdParty\FreeModbus\rtu
  library: MicroLIB
  memory RVCT4: ROM 0x8011000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: contest_irq_all.c contest_main.c systick.c
  group DeviceLib/BoardSupport
    ../DeviceLib/BoardSupport/: mcu_cmic_gd32f470vet6.c mcu_cmic_gd32f470vet6.h
  group DeviceLib/SpiFlash
    ../DeviceLib/SpiFlash/: gd25qxx.c lfs.c lfs_port.c lfs_util.c
  group DeviceLib/OledBus
    ../DeviceLib/OledBus/: oled.c
  group DeviceLib/KeyEngine
    ../DeviceLib/KeyEngine/: bit_array.h ebtn.c ebtn.h
  group DeviceLib/SdCard
    ../DeviceLib/SdCard/: sdio_sdcard.c
  group DeviceLib/ExternalAdc
    ../DeviceLib/ExternalAdc/: gd30ad3344.c
  group DeviceLib/FileSystem
    ../DeviceLib/FileSystem/: diskio.c ff.c
    ../DeviceLib/FileSystem/option/: ccsbcs.c
  group Driver
    ../Driver/: btn_app.c led_app.c oled_app.c usart_app.c sd_app.c rtc_app.c adc_app.c
  group Function/AppTask
    ../Function/AppTask/: scheduler.c
  group Peripherals
    ../Libraries/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../Libraries/: startup_gd32f450_470.s
  group CMSIS
    ../CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Utilities
    ../PACK/perf_counter-2.5.4/: perf_counter.c perfc_port_default.c systick_wrapper_ual.s
  group Protocol
    ../Protocol/: crc16.c protocol.c
  group Function
    ../Function/: app_params.c channel.c cmd_router.c comm.c storage.c alarm.c report.c rtc_time.c sleep.c timeutil.c ui.c sysctrl.c
  group Contest
    ../Function/: contest_adc.c contest_app.c contest_modbus.c contest_storage_final.c
  group FreeModbus
    ../ThirdParty/FreeModbus/: mb.c
    ../ThirdParty/FreeModbus/rtu/: mbrtu.c mbcrc.c
    ../ThirdParty/FreeModbus/functions/: mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../ThirdParty/FreeModbus/port/: contest_port_clocked.c
